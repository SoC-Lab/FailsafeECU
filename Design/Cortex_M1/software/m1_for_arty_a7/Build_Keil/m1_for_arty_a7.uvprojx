# Keil uVision project m1_for_arty_a7.uvprojx, settings and files
target m1_for_arty_a7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM1 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M1") CLOCK(12000000) ESEL ELITTLE
  output: m1_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\Cortex_M1_0\include;..\main;..\platform;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM1/: system_ARTY_CM1.c startup_ARTY_CM1.s
  group Standalone_v6_6
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/standalone_v6_6/src/: outbyte.c xil_assert.c print.c
  group Main
    ../main/: main.c
    ../uart/: uart.c
  group GPIO_source_files
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/gpio_v4_3/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
  group UART
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
target m1_for_arty_a7_sim (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m1_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 SIM_BUILD
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.1.2
